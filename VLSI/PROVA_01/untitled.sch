** sch_path: VLSI/PROVA_01/untitled.sch
**.subckt untitled
x1 vdd vin vout GND not_1
V1 vdd GND 0
V2 vin GND 0
R1 vout GND 100k m=1
**.ends
.GLOBAL GND
.end
